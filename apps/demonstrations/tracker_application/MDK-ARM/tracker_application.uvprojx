# Keil uVision project tracker_application.uvprojx, settings and files
target tracker_application (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tracker_application +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../bin/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 tracker_application/tracker_application.hex -Intel -o ../bin/tracker_application.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,LR1110TRK1XKS,STM32WB55xx,USE_FULL_LL_DRIVER,LR11XX,LR11XX_TRANSCEIVER,ENABLE_MODEM_GNSS_FEATURE,SMTC_TRACKER,REGION_EU_868,REGION_US_915,LR11XX_DEFINED_JOIN_PARAMETERS,USE_LR11XX_CE, USE_PRE_PROVISIONED_FEATURES,RP2_101,TASK_EXTENDED_1,TASK_EXTENDED_2,ENABLE_FAST_CLOCK_SYNC,MW_DBG_TRACE=1,
  c include: ..\..\..\..\apps\common;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\lr11xx_driver\src;..\..\..\..\host_driver\STMicroelectronics\STM32WBxx\Drivers\STM32WBxx_HAL_Driver\Inc\Legacy;..\..\..\..\host_driver\STMicroelectronics\STM32WBxx\Drivers\STM32WBxx_HAL_Driver\Inc;..\..\..\..\host_driver\STMicroelectronics\STM32WBxx\Drivers\CMSIS\Include;..\..\..\..\host_driver\STMicroelectronics\STM32WBxx\Drivers\CMSIS\Device\ST\STM32WBxx\Include;..\..\..\..\host_driver\STMicroelectronics\STM32WBxx\hal_config;..\..\..\..\smtc_hal\inc;..\..\..\..\smtc_hal\STMicroelectronics\STM32WB55xx\smtc_modem_hal;..\..\..\..\smtc_hal\STMicroelectronics\STM32WB55xx\inc;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_drivers\lr11xx_driver;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\lr11xx_crypto_engine;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_config;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_core;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_supervisor;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\device_management;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\alc_sync;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\almanac_update;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_b;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\radio_planner\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\soft_secure_element;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lorawan_api;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\..\..\..\lora_basics_modem\lora_basics_modem\smtc_modem_hal;..\..\..\..\lora_basics_modem\lora_basics_modem\;..\..\..\..\smtc_event;..\..\..\..\smtc_hal\board\lr1110trk1xks;..\..\..\..\smtc_hal\board\;..\..\tracker_application;..\tracker_utility;..\middleware\ble;..\middleware\ble\app;..\middleware\ble\lpm\tiny_lpm;..\middleware\ble\sequencer;..\middleware\ble\STM32_WPAN;..\middleware\ble\STM32_WPAN\interface\patterns\ble_thread\shci;..\middleware\ble\STM32_WPAN\interface\patterns\ble_thread\tl;..\middleware\ble\STM32_WPAN\interface\patterns\ble_thread;..\middleware\ble\STM32_WPAN\utilities;..\middleware\ble\STM32_WPAN\ble\core;..\middleware\ble\STM32_WPAN\ble\core\auto;..\middleware\ble\STM32_WPAN\ble\core\template;..\middleware\ble\STM32_WPAN\ble\svc\Inc;..\middleware\ble\STM32_WPAN\ble\svc\Src;..\middleware\ble\STM32_WPAN\ble;..\..\..\..\shields\LR11XX\LR1110TRK1xKS\BSP\peripherals\Leds;..\..\..\..\shields\LR11XX\LR1110TRK1xKS\BSP\peripherals\hall_effect;..\..\..\..\shields\LR11XX\LR1110TRK1xKS\BSP\peripherals\lis2de12;..\..\..\..\shields\LR11XX\LR1110TRK1xKS\BSP\peripherals\usr_button;..\..\..\..\shields\LR11XX\LR1110TRK1xKS\BSP\board;..\..\..\..\shields\LR11XX\LR1110TRK1xKS\BSP\ral_bsp;..\..\..\..\shields\LR11XX\radio_drivers_hal;..\..\..\..\shields\LR11XX\Helpers;..\..\..\..\shields\LR11XX\smtc_lr11xx_board;..\..\..\..\shields\interface;..\..\..\..\geolocation_middleware\bsp;..\..\..\..\geolocation_middleware\common;..\..\..\..\geolocation_middleware\gnss\src;..\..\..\..\geolocation_middleware\wifi\src;..\..\..\..\lora_basics_modem\printers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000008 size 0x2fff8
  scatter file: .\stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
  group Application/MDK-ARM
    ../../../../host_driver/STMicroelectronics/STM32WBxx/Drivers/CMSIS/Device/ST/STM32WBxx/Source/Templates/arm/: startup_stm32wb55xx_cm4.s
  group Application/User
    ../: main_tracker_application.c main_tracker_update_lr1110.c
  group tracker_utility
    ../tracker_utility/: tracker_utility.c
  group apps_modem_common
    ../../../../apps/common/: apps_modem_event.c apps_modem_common.c apps_utilities.c
    ../../../../lora_basics_modem/printers/: smtc_modem_api_str.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../host_driver/STMicroelectronics/STM32WBxx/Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rng.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_lptim.c stm32wbxx_ll_rtc.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_ll_spi.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_wwdg.c stm32wbxx_hal_iwdg.c stm32wbxx_hal.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_hsem.c stm32wbxx_hal_cortex.c
  group Drivers/CMSIS
    ../../../../host_driver/STMicroelectronics/STM32WBxx/Drivers/CMSIS/Device/ST/STM32WBxx/Source/Templates/: system_stm32wbxx.c
  group Drivers/BSP/Components
    ../../../../shields/LR11XX/LR1110TRK1xKS/BSP/peripherals/Leds/: leds.c
    ../../../../shields/LR11XX/LR1110TRK1xKS/BSP/peripherals/hall_effect/: hall_effect.c
    ../../../../shields/LR11XX/LR1110TRK1xKS/BSP/peripherals/lis2de12/: lis2de12.c
    ../../../../shields/LR11XX/LR1110TRK1xKS/BSP/peripherals/usr_button/: usr_button.c
  group radio_driver
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/radio_drivers/lr11xx_driver/src/: lr11xx_bootloader.c lr11xx_crypto_engine.c lr11xx_driver_version.c lr11xx_gnss.c lr11xx_radio.c lr11xx_regmem.c lr11xx_system.c lr11xx_wifi.c lr11xx_lr_fhss.c
  group board
    ../../../../shields/LR11XX/LR1110TRK1xKS/BSP/board/: lr1110_trk1xks_board.c
  group smtc_modem_hal
    ../../../../smtc_hal/STMicroelectronics/STM32WB55xx/smtc_modem_hal/: smtc_modem_hal.c
  group smtc_hal
    ../../../../smtc_hal/STMicroelectronics/STM32WB55xx/src/: smtc_hal_adc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_lp_timer.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_tmr_list.c smtc_hal_trace.c smtc_hal_uart.c smtc_hal_watchdog.c
  group radio_hal
    ../../../../shields/LR11XX/radio_drivers_hal/: lr11xx_hal.c
  group radio_ral
    ../../../../shields/LR11XX/LR1110TRK1xKS/BSP/ral_bsp/: ral_lr11xx_bsp.c
  group smtc_modem_services
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/almanac_update/: almanac_update.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/alc_sync/: alc_sync.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/file_upload/: file_upload.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/stream/: rose.c stream.c
  group smtc_ral
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_ral/src/: ral_lr11xx.c
  group smtc_ralf
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_ralf/src/: ralf_lr11xx.c
  group smtc_modem_crypto
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/lr11xx_crypto_engine/: lr11xx_ce.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/soft_secure_element/: aes.c cmac.c soft_se.c
  group smtc_modem_core
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lorawan_api/: lorawan_api.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/device_management/: dm_downlink.c modem_context.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_core/: smtc_modem.c smtc_modem_test.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_services/: fifo_ctrl.c lorawan_certification.c modem_utilities.c smtc_modem_services_hal.c smtc_clock_sync.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/modem_supervisor/: modem_supervisor.c
  group lr1mac
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: smtc_real.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c smtc_multicast.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/lr1mac_class_b/: smtc_beacon_sniff.c smtc_d2d.c smtc_ping_slot.c
  group radio_planner
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/radio_planner/src/: radio_planner.c radio_planner_hal.c
  group smtc_region
    ../../../../lora_basics_modem/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: region_eu_868.c region_us_915.c
  group middleware/bsp
    ../../../../shields/LR11XX/LR1110TRK1xKS/BSP/mw_bsp/: mw_bsp.c
  group middleware/common
    ../../../../geolocation_middleware/common/: mw_common.c
  group middleware/gnss
    ../../../../geolocation_middleware/gnss/src/: gnss_helpers.c gnss_middleware.c gnss_queue.c
  group middleware/wifi
    ../../../../geolocation_middleware/wifi/src/: wifi_helpers.c wifi_middleware.c
  group Application/User/STM32_WPAN/App
    ../middleware/ble/app/: app_ble.c ble_thread.c p2p_server_app.c
  group Application/User/STM32_WPAN/Target
    ../middleware/ble/target/: hw_ipcc.c
  group Middlewares/STM32_WPAN
    ../middleware/ble/STM32_WPAN/interface/patterns/ble_thread/tl/: tl_mbox.c hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c
    ../middleware/ble/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
    ../middleware/ble/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../middleware/ble/STM32_WPAN/ble/core/template/: osal.c
    ../middleware/ble/STM32_WPAN/ble/core/auto/: ble_events.c ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../middleware/ble/STM32_WPAN/ble/svc/Src/: p2p_stm.c svc_ctl.c
  group middleware/ble
    ../middleware/ble/: app_debug.c app_entry.c hw_timerserver.c stm32_lpm_if.c
    ../middleware/ble/lpm/tiny_lpm/: stm32_lpm.c
    ../middleware/ble/sequencer/: stm32_seq.c
target tracker_lr1110_update (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WB55CGUx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.2.0
  cpu: as above
  output: tracker_application +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  AfterMake: srecord\srec_cat.exe ../bin/BLE_Ota.hex -Intel -fill 0xFF 0x08000000 0x08007000 tracker_application/tracker_application.hex -Intel -o ../bin/tracker_lr1110_update.hex -Intel
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000008 size 0x2fff8
  scatter file: .\stm32wb55xx_flash_cm4.sct
  link misc: --keep *.o(TAG_OTA_START)
--keep *.o(TAG_OTA_END)
software components: CMSIS:CORE 5.4.0
